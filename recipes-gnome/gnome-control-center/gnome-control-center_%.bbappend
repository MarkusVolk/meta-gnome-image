PACKAGECONFIG:append = " cups"

