PACKAGECONFIG:append = " search_provider"
