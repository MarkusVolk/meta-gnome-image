PACKAGECONFIG:append:class-target = " cloudproviders tracker3"
