PACKAGECONFIG:append = " libwacom remote-desktop gnome-desktop sound-player"
