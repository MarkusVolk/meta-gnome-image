PACKAGECONFIG:append:class-target = " goa weather kerberos"

GI_DATA_ENABLED="True"
