PACKAGECONFIG:append = " bubblewrap libavif gamepad gst-transcoder"
