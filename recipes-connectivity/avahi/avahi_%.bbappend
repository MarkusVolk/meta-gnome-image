PACKAGECONFIG:append = " gtk3 libevent"

FILES:${PN} += "  \
    /usr/lib/libavahi-libevent.so.1.0.0 \
    /usr/lib/libavahi-libevent.so.1 \
"


