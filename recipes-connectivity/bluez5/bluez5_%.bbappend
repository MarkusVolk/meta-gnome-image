PACKAGECONFIG:append = " midi sixaxis threads"

PACKAGECONFIG[ebook] = "--enable-obex --with-phonebook=ebook,libical evolution-data-server"
