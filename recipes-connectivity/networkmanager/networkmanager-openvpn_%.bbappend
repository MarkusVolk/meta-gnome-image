PACKAGECONFIG:append = " gtk4"
