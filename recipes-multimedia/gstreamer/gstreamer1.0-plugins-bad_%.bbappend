PACKAGECONFIG:append = " faac assrender faad nettle kms lcms2 msdk opusparse rsvg rtmp sbc v4l2codecs va webrtcdsp"

